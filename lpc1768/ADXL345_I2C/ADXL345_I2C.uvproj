# Keil uVision project ADXL345_I2C.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ADXL345_I2C
  c flags: Optim=1
  c define: TARGET_LPC1768
  c include: mbed/LPC1768;.\mbed;.\mbed\.hg
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./: ADXL345_I2C.cpp main.cpp
    ./: ADXL345_I2C.h
    ./mbed/: mbed.h
    ../../../../lpc17xx.cmsis.driver.library/Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
