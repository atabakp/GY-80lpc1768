# Keil uVision project adxl345.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: adxl345 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s
    ../../../../lpc17xx.cmsis.driver.library/Drivers/source/: lpc17xx_i2c.c lpc17xx_uart.c lpc17xx_pinsel.c
  group main
    ./: main.c
    ../../../../lpc17xx.cmsis.driver.library/Drivers/include/: lpc17xx_libcfg_default.h
  group Driver
    ./: uart.h uart.c l3g4200d_driver.h
    ../../../../lpc17xx.cmsis.driver.library/Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c
  group CMSIS-CM3
    ../../../../lpc17xx.cmsis.driver.library/Core/CM3/CoreSupport/: core_cm3.c
    ../../../../lpc17xx.cmsis.driver.library/Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
